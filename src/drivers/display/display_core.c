#include "drivers/display/display_core.h"
#include "drivers/display/display_spi.h"

enum {
    DISPLAY_ORIGIN = 0,
    DISPLAY_WIDTH = 128,
    DISPLAY_HEIGHT = 160,
    DISPLAY_CHAR_WIDTH = 6,
    DISPLAY_CHAR_HEIGHT = 8,
    DISPLAY_FONT_WIDTH = 5,
    DISPLAY_FONT_HEIGHT = 7,
    DISPLAY_FONT_GLYPH_COUNT = 96,
    DISPLAY_ASCII_FIRST = 32,
    DISPLAY_ASCII_LAST = 127,
    DISPLAY_NEWLINE = '\n',
    DISPLAY_FALLBACK_CHAR = '?',
    DISPLAY_BYTES_PER_PIXEL = 2,
    DISPLAY_FILL_BUFFER_SIZE = 1024,
};

static const uint8_t font5x7[DISPLAY_FONT_GLYPH_COUNT][DISPLAY_FONT_WIDTH] = {
    {0x00,0x00,0x00,0x00,0x00}, {0x00,0x00,0x5F,0x00,0x00}, {0x00,0x07,0x00,0x07,0x00},
    {0x14,0x7F,0x14,0x7F,0x14}, {0x24,0x2A,0x7F,0x2A,0x12}, {0x23,0x13,0x08,0x64,0x62},
    {0x36,0x49,0x55,0x22,0x50}, {0x00,0x05,0x03,0x00,0x00}, {0x00,0x1C,0x22,0x41,0x00},
    {0x00,0x41,0x22,0x1C,0x00}, {0x14,0x08,0x3E,0x08,0x14}, {0x08,0x08,0x3E,0x08,0x08},
    {0x00,0x50,0x30,0x00,0x00}, {0x08,0x08,0x08,0x08,0x08}, {0x00,0x60,0x60,0x00,0x00},
    {0x20,0x10,0x08,0x04,0x02}, {0x3E,0x51,0x49,0x45,0x3E}, {0x00,0x42,0x7F,0x40,0x00},
    {0x42,0x61,0x51,0x49,0x46}, {0x21,0x41,0x45,0x4B,0x31}, {0x18,0x14,0x12,0x7F,0x10},
    {0x27,0x45,0x45,0x45,0x39}, {0x3C,0x4A,0x49,0x49,0x30}, {0x01,0x71,0x09,0x05,0x03},
    {0x36,0x49,0x49,0x49,0x36}, {0x06,0x49,0x49,0x29,0x1E}, {0x00,0x36,0x36,0x00,0x00},
    {0x00,0x56,0x36,0x00,0x00}, {0x08,0x14,0x22,0x41,0x00}, {0x14,0x14,0x14,0x14,0x14},
    {0x00,0x41,0x22,0x14,0x08}, {0x02,0x01,0x51,0x09,0x06}, {0x32,0x49,0x79,0x41,0x3E},
    {0x7E,0x11,0x11,0x11,0x7E}, {0x7F,0x49,0x49,0x49,0x36}, {0x3E,0x41,0x41,0x41,0x22},
    {0x7F,0x41,0x41,0x22,0x1C}, {0x7F,0x49,0x49,0x49,0x41}, {0x7F,0x09,0x09,0x09,0x01},
    {0x3E,0x41,0x49,0x49,0x7A}, {0x7F,0x08,0x08,0x08,0x7F}, {0x00,0x41,0x7F,0x41,0x00},
    {0x20,0x40,0x41,0x3F,0x01}, {0x7F,0x08,0x14,0x22,0x41}, {0x7F,0x40,0x40,0x40,0x40},
    {0x7F,0x02,0x04,0x02,0x7F}, {0x7F,0x04,0x08,0x10,0x7F}, {0x3E,0x41,0x41,0x41,0x3E},
    {0x7F,0x09,0x09,0x09,0x06}, {0x3E,0x41,0x51,0x21,0x5E}, {0x7F,0x09,0x19,0x29,0x46},
    {0x46,0x49,0x49,0x49,0x31}, {0x01,0x01,0x7F,0x01,0x01}, {0x3F,0x40,0x40,0x40,0x3F},
    {0x1F,0x20,0x40,0x20,0x1F}, {0x3F,0x40,0x38,0x40,0x3F}, {0x63,0x14,0x08,0x14,0x63},
    {0x07,0x08,0x70,0x08,0x07}, {0x61,0x51,0x49,0x45,0x43}, {0x00,0x7F,0x41,0x41,0x00},
    {0x02,0x04,0x08,0x10,0x20}, {0x00,0x41,0x41,0x7F,0x00}, {0x04,0x02,0x01,0x02,0x04},
    {0x40,0x40,0x40,0x40,0x40}, {0x00,0x01,0x02,0x04,0x00}, {0x20,0x54,0x54,0x54,0x78},
    {0x7F,0x48,0x44,0x44,0x38}, {0x38,0x44,0x44,0x44,0x20}, {0x38,0x44,0x44,0x48,0x7F},
    {0x38,0x54,0x54,0x54,0x18}, {0x08,0x7E,0x09,0x01,0x02}, {0x0C,0x52,0x52,0x52,0x3E},
    {0x7F,0x08,0x04,0x04,0x78}, {0x00,0x44,0x7D,0x40,0x00}, {0x20,0x40,0x44,0x3D,0x00},
    {0x7F,0x10,0x28,0x44,0x00}, {0x00,0x41,0x7F,0x40,0x00}, {0x7C,0x04,0x18,0x04,0x78},
    {0x7C,0x08,0x04,0x04,0x78}, {0x38,0x44,0x44,0x44,0x38}, {0x7C,0x14,0x14,0x14,0x08},
    {0x08,0x14,0x14,0x18,0x7C}, {0x7C,0x08,0x04,0x04,0x08}, {0x48,0x54,0x54,0x54,0x20},
    {0x04,0x3F,0x44,0x40,0x20}, {0x3C,0x40,0x40,0x20,0x7C}, {0x1C,0x20,0x40,0x20,0x1C},
    {0x3C,0x40,0x30,0x40,0x3C}, {0x44,0x28,0x10,0x28,0x44}, {0x0C,0x50,0x50,0x50,0x3C},
    {0x44,0x64,0x54,0x4C,0x44}, {0x00,0x08,0x36,0x41,0x00}, {0x00,0x00,0x7F,0x00,0x00},
    {0x00,0x41,0x36,0x08,0x00}, {0x08,0x04,0x08,0x10,0x08}, {0x00,0x00,0x00,0x00,0x00}
};

/************************************************
* display_core_init
* Initializes the low-level display transport.
* Parameters: none.
* Returns: void.
***************************************************/
void display_core_init(void)
{
    display_spi_init();
}

/************************************************
* display_core_fill_color
* Fills the full panel with a single RGB565 color.
* Parameters: color = RGB565 color value.
* Returns: void.
***************************************************/
void display_core_fill_color(uint16_t color)
{
    uint8_t buf[DISPLAY_FILL_BUFFER_SIZE];
    uint8_t hi = (uint8_t)(color >> 8);
    uint8_t lo = (uint8_t)(color & 0xFF);
    uint16_t pixels = (uint16_t)(DISPLAY_WIDTH * DISPLAY_HEIGHT);
    uint16_t bytes = (uint16_t)(pixels * DISPLAY_BYTES_PER_PIXEL);

    for (uint16_t i = 0; i < sizeof(buf); i += 2)
    {
        buf[i] = hi;
        buf[i + 1] = lo;
    }

    display_core_set_addr_window(DISPLAY_WIDTH, DISPLAY_HEIGHT);
    while (bytes)
    {
        uint16_t chunk = bytes > sizeof(buf) ? (uint16_t)sizeof(buf) : bytes;
        display_spi_write_buffer(buf, chunk);
        bytes = (uint16_t)(bytes - chunk);
    }
}

/************************************************
* display_core_set_addr_window
* Sets the active drawing area from (0,0) to width/height.
* Parameters: width = window width in pixels, height = window height in pixels.
* Returns: void.
***************************************************/
void display_core_set_addr_window(uint16_t width, uint16_t height)
{
    if (width == 0 || height == 0)
    {
        return;
    }
    display_spi_set_addr_window(DISPLAY_ORIGIN,
                                DISPLAY_ORIGIN,
                                (uint16_t)(width - 1u),
                                (uint16_t)(height - 1u));
}

/************************************************
* display_core_stream_bytes
* Writes raw pixel bytes to the current display window.
* Parameters: data = source bytes, len = byte count.
* Returns: void.
***************************************************/
void display_core_stream_bytes(const uint8_t *data, uint16_t len)
{
    display_spi_write_buffer(data, len);
}

/************************************************
* display_core_draw_char
* Renders one character into a fixed 6x8 RGB565 cell.
* Parameters: x/y = top-left pixel, c = character, fg/bg = RGB565 colors.
* Returns: void.
***************************************************/
void display_core_draw_char(uint16_t x, uint16_t y, char c, uint16_t fg, uint16_t bg)
{
    if (c < DISPLAY_ASCII_FIRST || c > DISPLAY_ASCII_LAST)
    {
        c = DISPLAY_FALLBACK_CHAR;
    }

    uint8_t idx = (uint8_t)(c - DISPLAY_ASCII_FIRST);
    uint8_t buf[DISPLAY_CHAR_WIDTH * DISPLAY_CHAR_HEIGHT * DISPLAY_BYTES_PER_PIXEL];
    uint16_t bi = 0;

    for (uint8_t row = 0; row < DISPLAY_CHAR_HEIGHT; row++)
    {
        for (uint8_t col = 0; col < DISPLAY_CHAR_WIDTH; col++)
        {
            uint16_t color = bg;
            if (col < DISPLAY_FONT_WIDTH && row < DISPLAY_FONT_HEIGHT)
            {
                uint8_t bits = font5x7[idx][col];
                if (bits & (1u << row))
                {
                    color = fg;
                }
            }
            buf[bi++] = (uint8_t)(color >> 8);
            buf[bi++] = (uint8_t)(color & 0xFF);
        }
    }

    display_spi_set_addr_window(x,
                                y,
                                (uint16_t)(x + DISPLAY_CHAR_WIDTH - 1u),
                                (uint16_t)(y + DISPLAY_CHAR_HEIGHT - 1u));
    display_spi_write_buffer(buf, sizeof(buf));
}

/************************************************
* display_core_draw_text
* Renders a null-terminated string using the built-in font.
* Parameters: x/y = top-left pixel, text = string, fg/bg = RGB565 colors.
* Returns: void.
***************************************************/
void display_core_draw_text(uint16_t x, uint16_t y, const char *text, uint16_t fg, uint16_t bg)
{
    if (!text)
    {
        return;
    }

    uint16_t cx = x;
    uint16_t cy = y;
    while (*text)
    {
        if (*text == DISPLAY_NEWLINE)
        {
            cx = x;
            cy = (uint16_t)(cy + DISPLAY_CHAR_HEIGHT);
            text++;
            continue;
        }
        display_core_draw_char(cx, cy, *text, fg, bg);
        cx = (uint16_t)(cx + DISPLAY_CHAR_WIDTH);
        text++;
    }
}
